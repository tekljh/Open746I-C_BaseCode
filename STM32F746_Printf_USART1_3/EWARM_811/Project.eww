<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_STM32F746_LED_IO_Printf_USART1_UART3_2017_1027B.ewp</path>
  </project>
  <batchBuild />
</workspace>
